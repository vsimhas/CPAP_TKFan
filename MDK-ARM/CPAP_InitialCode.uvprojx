# Keil uVision project CPAP_InitialCode.uvprojx, settings and files
target CPAP_InitialCode_CM4 (6230000::V6.23::ARMCLANG)
  device: STM32H747BITx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x10000000-0x10047FFF) IROM(0x8100000-0x81FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M4") TZ
  output: CPAP_InitialCode_CM4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORE_CM4,USE_HAL_DRIVER,STM32H747xx,USE_PWR_LDO_SUPPLY,ARM_MATH_CM4
  c include: ../CM4/Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../MCSDK_v6.4.2-Full/MotorControl/MCSDK/MCLib/Any/Inc;../MCSDK_v6.4.2-Full/MotorControl/MCSDK/MCLib/H7xx/Inc;../Common/Inc
  asm include: ../CM4/Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: stm32h747xx_flash_CM4.sct
  group Application/MDK-ARM
    ./: startup_stm32h747xx_CM7.s startup_stm32h747xx_CM4.s
  group Application/User/CM7/TouchGFX/App
    ../CM7/TouchGFX/App/: app_touchgfx.c
  group Application/User/CM7/TouchGFX/target
    ../CM7/TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/CM7/TouchGFX/target/generated
    ../CM7/TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/CM7/USB_DEVICE/Target
    ../CM7/USB_DEVICE/Target/: usbd_conf.c
  group Application/User/CM7/USB_DEVICE/App
    ../CM7/USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/CM7/Core
    ../CM7/Core/Src/: blower_ipc_cm7.c dbg_log.c telemetry_stream.c esp_bridge.c physiology_telem.c diagnostics_data.c blower_ctrl.c blower_osc.c flow_sensor.c tube_comp.c bench_playback.c leak_estimator.c leak_estimator_vivo.c leak_btps.c therapy.c safety_supervisor.c epr_ctrl.c apap_ctrl.c diskio_sd.c edf_writer.c session_edf_log.c rtc_clock.c session_summary.c adherence.c fault_log.c watchdog.c humidifier.c lcd_drv.c lcd_font.c lcd_test.c nfc_secure.c nfc_test.c pressure_sensors.c rfal_platform.c rotary_input.c sensirion_th.c sha256.c main.c freertos.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
    ../CM7/Middlewares/Third_Party/FatFs/src/: ff.c
    ../CM7/Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c
  group Application/User/CM4/Core
    ../CM4/Core/Src/: aspep.c blower_ipc_cm4.c hf_registers.c mc_api.c mc_app_hooks.c mc_config.c mc_config_common.c mc_configuration_registers.c mc_interface.c mc_math.c mc_parameters.c mc_tasks.c mc_tasks_foc.c mcp.c mcp_config.c motorcontrol.c pwm_common.c pwm_curr_fdbk.c pwm_curr_fdbk_ovm.c regular_conversion_manager.c speed_torq_ctrl.c stm32_mc_common_it.c stm32h7xx_mc_it.c sync_registers.c usart_aspep_driver.c main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_qspi.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Common/Src/: blower_ipc.c retarget_io.c semihost_disable.s cm7_cpu_config.c usagefault_handler_cm7.s system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers_v2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../cm7/middlewares/st/touchgfx/lib/core/cortex_m7/Keil6.x/: touchgfx_core_wchar16.lib
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group gui
    ../cm7/touchgfx/gui/src/cpap/: cpap_menu.cpp cpap_settings.cpp icon_widget.cpp status_icons.cpp
    ../cm7/touchgfx/gui/src/common/: frontendapplication.cpp
    ../cm7/touchgfx/gui/src/model/: model.cpp
    ../cm7/touchgfx/gui/src/screen_screen/: screenpresenter.cpp screenview.cpp
  group generated
    ../cm7/touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp compressedfontcache.cpp compressedunmappedfontcache.cpp font_verdana_10_4bpp_0.cpp font_verdana_20_4bpp_0.cpp font_verdana_40_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_20_4bpp.cpp kerning_verdana_40_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_20_4bpp.cpp table_verdana_40_4bpp.cpp unmappeddatafont.cpp vectorfontrendererbuffers.cpp
    ../cm7/touchgfx/generated/images/src/: bitmapdatabase.cpp svgdatabase.cpp
    ../cm7/touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../cm7/touchgfx/generated/images/src/__generated/: image_alternate_theme_images_backgrounds_480x272_puzzle.cpp image_alternate_theme_images_widgets_button_regular_height_50_medium_rounded_normal.cpp image_alternate_theme_images_widgets_button_regular_height_50_medium_rounded_pressed.cpp
    ../cm7/touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../cm7/touchgfx/generated/gui_generated/src/screen_screen/: screenviewbase.cpp
  group Middlewares/MotorControl
    ../MCSDK_v6.4.2-Full/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c mcpa.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c revup_ctrl.c speed_pos_fdbk.c virtual_speed_sensor.c sto_pll_speed_pos_fdbk.c
    ../MCSDK_v6.4.2-Full/MotorControl/MCSDK/MCLib/H7xx/Src/: r3_2_h7xx_pwm_curr_fdbk.c
  group Middleware/ST25RFAL
    ../CM7/Middleware/ST25RFAL/source/: rfal_analogConfig.c rfal_cd.c rfal_crc.c rfal_dlma.c rfal_dpo.c rfal_iso15693_2.c rfal_isoDep.c rfal_nfc.c rfal_nfca.c rfal_nfcb.c rfal_nfcDep.c rfal_nfcf.c rfal_nfcv.c rfal_st25tb.c rfal_st25xv.c rfal_t1t.c rfal_t2t.c rfal_t4t.c
    ../CM7/Middleware/ST25RFAL/source/st25r3916/: rfal_rfst25r3916.c st25r3916.c st25r3916_aat.c st25r3916_com.c st25r3916_irq.c st25r3916_led.c
target CPAP_InitialCode_CM7 (6230000::V6.23::ARMCLANG)
  device: STM32H747BITx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: CPAP_InitialCode_CM7 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORE_CM7,USE_HAL_DRIVER,STM32H747xx,USE_PWR_LDO_SUPPLY,ST25R3916B,NDEBUG
  c include: ../CM7/Core/Inc;../CM7/Middlewares/Third_Party/FatFs/src;../CM7/TouchGFX/App;../CM7/TouchGFX/target/generated;../CM7/TouchGFX/target;../CM7/USB_DEVICE/App;../CM7/USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/RTOS2/Include;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../cm7/middlewares/st/touchgfx/framework/include;../cm7/touchgfx/generated/fonts/include;../cm7/touchgfx/generated/gui_generated/include;../cm7/touchgfx/generated/images/include;../cm7/touchgfx/generated/texts/include;../cm7/touchgfx/generated/videos/include;../cm7/touchgfx/gui/include;../Common/Inc;../CM7/Middleware/ST25RFAL/include;../CM7/Middleware/ST25RFAL/source/st25r3916;../CM7/Middleware/ST25RFAL/source
  asm include: ../CM7/Core/Inc;../CM7/Middlewares/Third_Party/FatFs/src;../CM7/TouchGFX/App;../CM7/TouchGFX/target/generated;../CM7/TouchGFX/target;../CM7/USB_DEVICE/App;../CM7/USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/RTOS2/Include;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: stm32h747xx_flash_CM7.sct
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2
